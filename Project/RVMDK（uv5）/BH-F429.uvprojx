# Keil uVision project BH-F429.uvprojx, settings and files
target 工程模板 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ..\..\Output\update.bin ..\..\Output\Template.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=5
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,USE_EMBEDDED_PHY
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\HARDWARE;..\..\User\lcd;..\..\FATFS;..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\User\flash;..\..\HARDWARE\font;..\..\User\APP;..\..\User\RTC;..\..\Output;..\..\HARDWARE\1650;..\..\libscpi\inc\
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c pbdata.c user.c test.c scpi-def.c
  group DOC
    ../../: 必读说明.txt
  group HARDWARE
    ../../HARDWARE/: GPIO.C keyboard.c flash_eerom.c bsp_bmp.c
    ../../HARDWARE/lcd/: bsp_lcd.c
    ../../HARDWARE/font/: fonts.c
    ../../HARDWARE/flash/: bsp_spi_flash.c
    ../../HARDWARE/sdram/: bsp_sdram.c
    ../../HARDWARE/tim/: bsp_basic_tim.c
    ../../HARDWARE/usart/: bsp_debug_usart.c
    ../../HARDWARE/tim_pwm/: bsp_general_tim.c
    ../../HARDWARE/systick/: bsp_SysTick.c
    ../../HARDWARE/adc/: bsp_adc.c
    ../../User/RTC/: bsp_rtc.c
    ../../User/: bsp_exti.c
  group FATFS
    ../../FATFS/: diskio.c ff.c
    ../../FATFS/option/: cc936.c
  group APP
    ../../User/APP/: usb_bsp.c usbh_usr.c usbh_it.c
    ../../User/: flash_if.c
  group USB_Driver
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_hcd_int.c usb_hcd.c usb_core.c
  group USB_HOST
    ../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group libscpi
    ../../libscpi/src/: error.c expression.c fifo.c ieee488.c lexer.c minimal.c units.c parser.c utils.c fifo_private.h lexer_private.h parser_private.h utils_private.h
